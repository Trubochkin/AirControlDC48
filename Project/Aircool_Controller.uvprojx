# Keil uVision project Aircool_Controller.uvprojx, settings and files
target Aircool_Controller (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Aircool_Controller +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0xx,
  c include: ..\CMSIS;..\Source;..\StdLib\src;..\StdLib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/: system_stm32f0xx.c startup_stm32f030.s
  group StdLib
    ../StdLib/src/: stm32f0xx_adc.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_i2c.c
  group Source
    ../Source/: main.c main_ini.c stm32f0xx_it.c f_air_alarm.c f_air_control.c f_delays.c f_ds18b20.c f_flash.c f_modbus_slave.c
